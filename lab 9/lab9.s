ORG 0000H
//storing a lookup table for SSD.
	MOV R0,#40H
	MOV @R0,#3FH
	INC R0
	MOV @R0,#06H
	INC R0
	MOV @R0,#5BH
	INC R0
	MOV @R0,#4FH
	INC R0
	MOV @R0,#66H
	INC R0
	MOV @R0,#6DH
	INC R0
	MOV @R0,#7DH
	INC R0
	MOV @R0,#07H
	INC R0
	MOV @R0,#7FH
	INC R0
	MOV @R0,#67H
//---------
	MOV P2,#00H
	LOOP:	MOV R0,#40H
	MOV R2,#0AH
	LABEL:	MOV A,@R0
	MOV P2,A
	ACALL DELAY
	INC R0
	DJNZ R2,LABEL
	JMP LOOP	
	
	DELAY: MOV R3,#15H
	LABEL3:MOV R4,#200
	LABEL2:MOV R5,#200
	LABEL1:DJNZ R5,LABEL1
	DJNZ R4,LABEL2
	DJNZ R3,LABEL3
	RET
	END
	